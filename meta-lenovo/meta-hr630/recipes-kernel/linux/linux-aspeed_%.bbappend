FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append:hr630 = " \
    file://hr630.cfg \
"
