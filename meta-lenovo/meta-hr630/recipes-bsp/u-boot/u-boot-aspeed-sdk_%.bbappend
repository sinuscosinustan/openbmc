FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:hr630 = " file://hr630.cfg"
