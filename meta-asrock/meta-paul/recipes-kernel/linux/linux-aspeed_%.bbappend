FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append:paul = " \
    file://paul.cfg \
"
