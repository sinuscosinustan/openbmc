PACKAGECONFIG:remove = " static-dual-image"
