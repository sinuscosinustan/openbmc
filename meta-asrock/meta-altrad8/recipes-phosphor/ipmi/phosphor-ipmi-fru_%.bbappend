DEPENDS:append = " altrad8-yaml-config"

IPMI_FRU_YAML = "${STAGING_DIR_HOST}${datadir}/altrad8-yaml-config/ipmi-fru-read.yaml"
