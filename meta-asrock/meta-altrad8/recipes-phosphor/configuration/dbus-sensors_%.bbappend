PACKAGECONFIG:remove = " exitairsensor mcutempsensor"
