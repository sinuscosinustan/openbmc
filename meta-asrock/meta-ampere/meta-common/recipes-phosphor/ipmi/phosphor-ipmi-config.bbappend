# Note for the config: Channel 1 should be eth1 as this is the dedicated
# NIC (RTL8211).
FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
